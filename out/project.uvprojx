# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.2.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\src\hard;..\src\hard;..\src\hard;..\src\hard;..\src\hard;..\src\hard;..\src\hard;..\src\hard;..\src\user;..\src\hard;..\src\hard;..\src\hard;..\src\hard
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group user
    ../src/user/: main.c temperature.c
  group hard
    ../src/hard/: oled.c delay.c adc.c uart.c KEY.c i2c.c 24c02.c pwm.c beep.c ui.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
